options:
  parameters:
    generate_options: no_gui
    id: hackrf_file_tx_demo
    output_language: python
    run_options: run
    title: HackRF FLEX File TX Demo
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '931937500'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: hw_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps * baud_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * deviation / samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: encoded.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: '1'
    args: hackrf=0
    bb_gain0: '20'
    corr0: '0.8'
    freq0: center_freq
    gain0: '40'
    if_gain0: '20'
    sample_rate: hw_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // math.gcd(int(hw_rate), int(samp_rate)))
    interp: int(hw_rate // math.gcd(int(hw_rate), int(samp_rate)))
    type: ccc
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
